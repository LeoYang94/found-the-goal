# Keil uVision project STM32F4.uvproj, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED =1
  c include: ..\Libraries;..\Mylib;..\User;..\IMU;..\Vision;..\Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c CAN2.c my_func.c
  group Libraries
    ../Libraries/: misc.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_syscfg.c system_stm32f4xx.c startup_stm32f4xx.s stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_iwdg.c
  group Debug
    ../User/: led.c
    ../Mylib/: referee.c
  group Sys
    ../User/: sys.c delay.c clock.c
    ../Mylib/: referee.h
  group Sensor
    ../User/: 6050.c I2C.c Prepare_data.c
  group Holder
    ../User/: Holder.c Remote.c Motor_out.c Ramp.c
    ./: auto_shoot.c
  group Chassis
    ../User/: Chassis_Control.c Wheel_Speed.c
    ../Mylib/: PowerLimit.c
  group Acurator
    ../Mylib/: Shoot.c Load_motor.c
  group DataSave
    ../User/: BKP_DATA.c
  group WatchDog
    ../User/: MyWDG.c
  group Esay
    ../User/: OtherConfig.c
  group IMU
    ../IMU/: imu.c
  group Vision
    ../Vision/: Hit.c Hit_calculation.c
